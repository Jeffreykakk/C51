# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\1.0模块化编程
  group Source Group 1
    ./: STARTUP.A51 main.c
    ../1.0模块化编程/: display.c
